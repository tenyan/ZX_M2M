# Keil uVision project ZXM2M_ST_V001.uvprojx, settings and files
target ZXM2M_ST_V001 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F205VETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ZXM2M_ST_V001 +hex
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F2XX
  c misc: --diag_suppress=870
  c include: .\USER;.\USER\BlindZone;.\USER\CAN;.\USER\Cellura;.\USER\Collect;.\USER\GB17691;.\USER\GPS;.\USER\HJ;.\USER\Memory;.\USER\Misc;.\USER\PcDebug;.\USER\System;.\Lib\STM32F2xx_StdPeriph_Driver\inc;.\RTE\Device\STM32F2xx;.\USER\M2M;.\USER\RTC;.\USER\Momi;.\USER\AuxCom
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Project\ZXM2M_ST_V001.sct
  group USER
    ./USER/: HardFaultHandler.c HardFaultHandler.S main.c main.h types.h config.h
    ./RTE/Device/STM32F2xx/: startup_stm32f2xx.s system_stm32f2xx.c system_stm32f2xx.h
  group Collect
    ./USER/Collect/: CollectHW.c CollectHW.h Collect.c Collect.h CollectModule.h
  group CAN
    ./USER/CAN/: CanHW.c CanHW.h Can.c Can.h tcw.c tcw.h
  group Memory
    ./USER/Memory/: sfud.c sfud.h parameters.c parameters.h fal.c fal.h FlashDB.c FlashDB.h
  group PcDebug
    ./USER/PcDebug/: PcDebugHW.c PcDebugHW.h PcDebug.c PcDebug.h
  group Momi
    ./USER/Momi/: MomiHw.c MomiHw.h MomiProtocol.c MomiProtocol.h
  group M2M
    ./USER/M2M/: M2mProtocol.h M2mProtocol.c
  group System
    ./USER/System/: iap.c iap.h tbox_machine.c tbox_machine.h icloud_machine.c icloud_machine.h
  group RTC
    ./USER/RTC/: am1805.c am1805.h i2c1.c i2c1.h rtc.c rtc.h
  group Misc
    ./USER/Misc/: led.c led.h crc32.c crc32.h md5.c md5.h
  group FWLib
    ./Lib/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c misc.c stm32f2xx_rtc.c
  group AuxCom
    ./USER/AuxCom/: AuxCom.c AuxCom.h AuxComHW.c AuxComHW.h
software components: RTOS:Config 10.2.0, RTOS:Core 10.2.0, RTOS:Event Groups 10.2.0, RTOS:Heap 10.2.0, RTOS:Message Buffer 10.2.0, RTOS:Timers 10.2.0, CMSIS:CORE 5.2.0, CMSIS:RTOS2:FreeRTOS 10.2.0
