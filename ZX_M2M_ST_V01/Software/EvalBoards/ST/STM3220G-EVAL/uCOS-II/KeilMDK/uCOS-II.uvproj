# Keil uVision project uCOS-II.uvproj, settings and files
target FLASH (ARM-ADS)
  device: STM32F205VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: uCOS-II +hex
  AfterMake: C:\keil\ARM\BIN40\fromelf.exe --bin -o ./Output/uCOS-II.bin ./Output/uCOS-II.axf
  c define: USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\..\uCOS-II;..\..\uCOS-II\KeilMDK;..\..\BSP;..\..\BSP\OS\uCOS-II;..\..\BSP\STM32F2xx\inc;..\..\BSP\CMSIS;..\..\BSP\CMSIS\Device_Support;..\..\..\..\..\uC-CPU;..\..\..\..\..\uC-CPU\ARM-Cortex-M3\RealView;..\..\..\..\..\uC-LIB;..\..\..\..\..\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\..\..\..\..\uCOS-II\Source;..\..\..\..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView;..\..\..\..\..\..\User\Collect;..\..\..\..\..\..\User\GPS;..\..\..\..\..\..\User\GSM;..\..\..\..\..\..\User\Lib;..\..\..\..\..\..\User\MCU;..\..\..\..\..\..\User\PC;..\..\..\..\..\..\User\System;..\..\..\..\..\..\User\A5Com;..\..\..\..\..\..\User\Time;..\..\..\..\..\..\User\Memory;..\..\..\..\..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\Output\uCOS-II.sct
  group APP
    ./: app_cfg.h lib_cfg.h
    ../: app.c app_hooks.c cpu_cfg.h includes.h os_cfg.h stm32f4xx.h stm32f4xx_conf.h
    ../../BSP/CMSIS/Device_Support/: system_stm32f2xx.c system_stm32f2xx.h
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c bsp_ioe.c bsp_ioe.h bsp_lcd.c bsp_lcd.h bsp_ser.c bsp_ser.h
    ../../BSP/OS/uCOS-II/: bsp_os.c bsp_os.h
    ../../BSP/KeilMDK/: startup_stm32f2xx.s
  group uC/CPU
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../../../../uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../../../../uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-II Source
    ../../../../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC/OS-II Port
    ../../../../../uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group STM32F2xx Library
    ../../BSP/STM32F2xx/inc/: misc.h stm32f2xx_adc.h stm32f2xx_can.h stm32f2xx_crc.h stm32f2xx_cryp.h stm32f2xx_dac.h stm32f2xx_dbgmcu.h stm32f2xx_dcmi.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_flash.h stm32f2xx_fsmc.h stm32f2xx_gpio.h stm32f2xx_hash.h stm32f2xx_i2c.h stm32f2xx_iwdg.h stm32f2xx_pwr.h stm32f2xx_rcc.h stm32f2xx_rng.h stm32f2xx_rtc.h stm32f2xx_sdio.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h stm32f2xx_wwdg.h
    ../../BSP/STM32F2xx/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Collect
    ../../../../../../User/Collect/: CollectCompositelayer.c CollectCompositelayer.h CollectInterfaceLayer.c CollectInterfaceLayer.h CollectModule.h CollectHW.c CollectHW.h
  group GSM
    ../../../../../../User/GSM/: GsmHardWareLayer.c GsmHardWareLayer.h GsmIntegrateLayer.c GsmIntegrateLayer.h GsmModule.h GsmProtocolLayer.c GsmProtocolLayer.h
  group Lib
    ../../../../../../User/Lib/: BaseFun.c BaseFun.h
  group MCU
    ../../../../../../User/MCU/: Mcu.c Mcu.h McuHW.c McuHW.h McuUpload.c McuChQiUpload.c
  group PC
    ../../../../../../User/PC/: PcDebug.c PcDebug.h PcHardware.c PcHardware.h
  group System
    ../../../../../../User/System/: SystemCommand.c SystemCommand.h SystemModule.h SystemProtocol.c SystemProtocol.h SystemWorkMode.c SystemWorkMode.h IAP.c IAP.h
  group Time
    ../../../../../../User/Time/: rtc.c rtc.h amx8xx_v00.h amx8xx_v02.c i2c.c
  group Memory
    ../../../../../../User/Memory/: MX25L1606Mem.c MX25L1606Mem.h
  group A5Com
    ../../../../../../User/A5Com/: A5_Com1HW.c A5_Com1ProtocolLayer.c
  group GPS
    ../../../../../../User/GPS/: GpsProtocolLayer.c
